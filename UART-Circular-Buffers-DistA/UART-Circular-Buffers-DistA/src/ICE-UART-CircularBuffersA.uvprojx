# Keil uVision project ICE-UART-CircularBuffersA.uvprojx, settings and files
target ICE-UART-CircularBuffers (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(80000000) ELITTLE
  output: ece353_base_project
  c flags: Optim=1
  c include: C:\Keil_v5\ARM\Pack\ARM\CMSIS\3.20.4\CMSIS\Include;..\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: main.c boardUtil.c interrupts.c
  group lib
    ../lib/: uart-produer-consumer.lib
  group drivers
    ../drivers/: gpioPort.c uart.c pc_buffer.c
  group ::Device
    RTE/Device/TM4C123GH6PM/: startup_TM4C123.s system_TM4C123.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0
